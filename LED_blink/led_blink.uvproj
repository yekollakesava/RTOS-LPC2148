# Keil uVision project led_blink.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: led_blink +hex
  c flags: Optim=1
  c define: ARM7_LPC21xx_KEIL_RVDS KEIL_THUMB_INTERWORK
  c include: C:\Keil\FreeRTOS_V9.0.0rc2\FreeRTOS\Demo\Common\include;C:\Keil\FreeRTOS_V9.0.0rc2\FreeRTOS\Source\portable\RVDS\ARM7_LPC21xx;C:\Keil\FreeRTOS_V9.0.0rc2\FreeRTOS\Source\include
  asm include: C:\Keil\FreeRTOS_V9.0.0rc2\FreeRTOS\Source\portable\RVDS\ARM7_LPC21xx
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    C:/Keil/FreeRTOS_V9.0.0rc2/FreeRTOS/Source/portable/MemMang/: heap_4.c
    C:/Keil/FreeRTOS_V9.0.0rc2/FreeRTOS/Source/: list.c queue.c tasks.c
    C:/Keil/FreeRTOS_V9.0.0rc2/FreeRTOS/Source/include/: FreeRTOSConfig.h
    C:/Keil/FreeRTOS_V9.0.0rc2/FreeRTOS/Source/portable/RVDS/ARM7_LPC21xx/: port.c portASM.s
    C:/Users/yekol/Downloads/: Startup.s
    ../practice/: led.c
